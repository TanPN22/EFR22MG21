# IAR project ZB_GeckoBootloader_efr32.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: EFR32MG13P632F512GM48 SiliconLaboratories EFR32MG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFR32MG13P632F512GM48; BTL_CONFIG_FILE="bootloader-configuration.h"; BTL_SLOT_CONFIGURATION="bootloader-slot-configuration.h"; SL_RAMFUNC_DISABLE; BOOTLOADER_VERSION_MAIN_CUSTOMER=3; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"; USE_SE_IN_IRQ=1; HAL_CONFIG=1; EMBER_AF_USE_HWCONF
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\Device\SiliconLabs\EFR32MG13P\Include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\CMSIS\Include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\halconfig\inc\hal-config; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\..\hardware\module\config; hal-config; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\emdrv\common\inc; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\emlib\inc; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\configs; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\src\cryptoacc\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\src\cryptoacc\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BTL_CONFIG_FILE="bootloader-configuration.h"; BTL_SLOT_CONFIGURATION="bootloader-slot-configuration.h"; SL_RAMFUNC_DISABLE; BOOTLOADER_VERSION_MAIN_CUSTOMER=3; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"; USE_SE_IN_IRQ=1; HAL_CONFIG=1; EMBER_AF_USE_HWCONF
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\Device\SiliconLabs\EFR32MG13P\Include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\CMSIS\Include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\halconfig\inc\hal-config; hal-config; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\emdrv\common\inc; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\emlib\inc; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\configs; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\src\cryptoacc\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\src\cryptoacc\src
  OBJCOPY.OOCOutputFile: ZB_GeckoBootloader.s37
  ILINK.IlinkOutputFile: ZB_GeckoBootloader.out
  ILINK.IlinkIcfFile: D:\DH\Lumi\Zigbee\SimplicityStudio\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.7/platform/bootloader/core/IAR/main_btl_bootloader_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EFR32MG13P632F512GM48; BTL_CONFIG_FILE="bootloader-configuration.h"; BTL_SLOT_CONFIGURATION="bootloader-slot-configuration.h"; SL_RAMFUNC_DISABLE; BOOTLOADER_VERSION_MAIN_CUSTOMER=3; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"; USE_SE_IN_IRQ=1; HAL_CONFIG=1; EMBER_AF_USE_HWCONF
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\Device\SiliconLabs\EFR32MG13P\Include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader\..\CMSIS\Include; hal-config; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\bootloader; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\emdrv\common\inc; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\platform\emlib\inc; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\configs; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\src\cryptoacc\include; ..\..\v4\developer\sdks\gecko_sdk_suite\v2.7\util\third_party\mbedtls\sl_crypto\src\cryptoacc\src
  group (top)
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/build/lib/: libbootloader_efx32xg13_iar.a libparser_efx32xg13_iar.a libstorage_efx32xg13_iar.a
    ./: bootloader-callback-stubs.c bootloader-callbacks.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/core/: btl_core.c btl_main.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/core/IAR/: main_btl_startup.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/driver/: btl_driver_util.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/plugin/parser/: btl_image_parser.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/plugin/parser/ebl/: btl_gbl_custom_tags.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/plugin/security/: btl_crc16.c btl_crc32.c btl_security_aes.c btl_security_ecdsa.c btl_security_sha256.c btl_security_tokens.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/plugin/security/ecc/: ecc.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/plugin/storage/: btl_storage.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/plugin/storage/internal_flash/: btl_storage_internal_flash.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_crypto.c em_emu.c em_eusart.c em_gpio.c em_msc.c em_rmu.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/util/third_party/mbedtls/sl_crypto/src/: crypto_aes.c crypto_management.c crypto_sha.c cryptoacc_aes.c cryptoacc_management.c cryptoacc_sha.c se_aes.c se_management.c se_sha.c shax.c
  group Device
    ../../v4/developer/sdks/gecko_sdk_suite/v2.7/platform/bootloader/../Device/SiliconLabs/EFR32MG13P/Source/: system_efr32mg13p.c
